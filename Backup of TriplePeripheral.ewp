# IAR project Backup of TriplePeripheral.ewp, settings and files
configuration CC2540DK-MINI Keyfob (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\phy; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\npi\npi_np; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2540 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\phy; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\npi\npi_np; Profiles\Roles; Profiles\SimpleProfile; Profiles\DevInfo
configuration CC2540F128DK-MINI Keyfob (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2540F128 CC2540F128
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\phy; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\npi\npi_np; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\Profiles\Roles; Profiles\SimpleProfile; Profiles\Keys; Profiles\DevInfo
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540\ti_51ew_cc2540f128b.xcl
configuration CC2540F128 (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2540F128 CC2540F128
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\phy; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo
  XLINK.XclFile: as above
configuration CC2540-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\phy; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\controller\include; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\npi\npi_np; C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-OAD-ImgA\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2540-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-OAD-ImgB\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540\cc254x_f256_imgB.xcl
configuration CC2540-OAD-Encrypted-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_SECURE; FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-OAD-Encrypted-ImgA\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540\cc254x_f256_imgAe.xcl
configuration CC2540-OAD-Encrypted-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_SECURE; FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2540-OAD-Encrypted-ImgB\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.1.43908a\Projects\ble\common\cc2540\cc254x_f256_imgBe.xcl
  group HAL/Common
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/hal/common/: hal_drivers.c
  group HAL/Include
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/ble/host/: linkdb.h
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/ble/include/: bcomdef.h
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h peripheralBroadcaster.c peripheralBroadcaster.h
    ../../Include/: gapgattserver.h gattservapp.h
    C:/Texas Instruments/BLE-CC254x-1.4.1.43908a/Components/ble/host/: gatt_uuid.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/SimpleProfile/: simpleGATTprofile.c simpleGATTprofile.h
    ../../Profiles/Keys/: simplekeys.c simplekeys.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
